# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64D4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User;.\Drivers;.\STC8Ax_LIB\Core\Startup;.\STC8Ax_LIB\inc;.\STC8Ax_LIB\Core
  group STC8Ax_LIB
    ./STC8Ax_LIB/src/: STC8Ax_DELAY.c STC8Ax_GPIO.c
  group User
    ./User/: main.c stc8Ax_Init.c AD.c DigLED.c stc8Ax_ISR.c uart_printf.c ntc_temp_calc.c KeyScan.c
