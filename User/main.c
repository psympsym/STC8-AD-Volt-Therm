/*-------------------------------------------------------------------
/*      (C) Copyright 2021-2022, nbufe. All Rights Reserved
/*-------------------------------------------------------------------
/* File name   : main.c
/* Description :
/* Author      : nbufe
/*-------------------------------------------------------------------
/* Update note:
/* ---------   -----------   ----------------------------------------
/*   Date        Author                       Note
/* ---------   -----------   ----------------------------------------
/*
/*
**/

/* 包含头文件 -------------------------------------------------------*/
#include "main.h"

/* 私有类型定义 -----------------------------------------------------*/
/* None. */

/* 私有宏定义 -------------------------------------------------------*/
/* None. */

/* 私有变量 ---------------------------------------------------------*/
uint8 i = 0;

/* 扩展变量 ---------------------------------------------------------*/
/* None. */

/* 私有函数原形 -----------------------------------------------------*/
/* None. */

/* 函数体 -----------------------------------------------------------*/
/*
 * 功能: 主函数
 * 参数: None
 * 返回: None
 * 说明: None
 */
void main()
{
    System_Init();
    Delay_ms(500);
    Peripheral_Init();
    while(1)
    {
		Sampl();
		if (++i % 10 == 0)
		{
			// 设置数码管显示
			if (flag)
			{
				DisplayLoad(3, voltage / 10000 % 10, 0);
				DisplayLoad(2, voltage / 1000 % 10, 1);
				DisplayLoad(1, voltage / 100 % 10, 0);
				DisplayLoad(0, voltage / 10 % 10, 0);
				printf("voltage=%.3fV", voltage / 1000.0);
			}
			else
			{
				DisplayLoad(3, tmp / 10 % 10, 0);
				DisplayLoad(2, tmp % 10, 0);
				DisplayLoad(1, 10, 0);
				DisplayLoad(0, 11, 0);
				printf("tmp=%d℃", tmp);
			}
		}
		Delay_ms(50);
    }
}



/*>>>>>>>>>> (C) COPYRIGHT NBUFE <<<<<< >>>>>> END OF FILE <<<<<<<<<<*/
